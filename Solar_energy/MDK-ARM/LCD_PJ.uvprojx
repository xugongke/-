# Keil uVision project LCD_PJ.uvprojx, settings and files
target LCD_PJ (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LCD_PJ +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./BIN/LCD_PJ.bin ./LCD_PJ/LCD_PJ.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --diag_suppress=870 --diag_suppress=188 --diag_suppress=546 --diag_suppress=111
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/LVGL_v8.3.11/lvgl;../Middlewares/LVGL_v8.3.11/lvgl/src;../Middlewares/LVGL_v8.3.11/lvgl/examples;../Middlewares/LVGL_v8.3.11/lvgl/examples/porting;../Middlewares/LVGL_v8.3.11/lvgl/src/hal;../Middlewares/LVGL_v8.3.11/lvgl/src/misc;../Middlewares/LVGL_v8.3.11/lvgl/src/core;../Middlewares/LVGL_v8.3.11/lvgl/src/draw/stm32_dma2d;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/LVGL_v8.3.11/lvgl/myGUI/custom;../Middlewares/LVGL_v8.3.11/lvgl/myGUI/generated;../Middlewares/LVGL_v8.3.11/lvgl/myGUI/generated/guider_customer_fonts;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Middlewares/W5500;../Middlewares/W5500/ioLibrary_Driver/Ethernet;../Middlewares/W5500/ioLibrary_Driver/Ethernet/W5500;../Middlewares/W5500/ioLibrary_Driver/Internet/DHCP;../Middlewares/W5500/wiz_interface;../Middlewares/W5500/wiz_platform;../Middlewares/W5500/user_main;../Middlewares/W5500/ioLibrary_Driver/Internet/SNTP;../Middlewares/W5500/DNS;../Middlewares/W5500/ioLibrary_Driver/Internet/DNS;../Middlewares/W5500/Loopback;../Middlewares/W5500/interrupt
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8080000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: LCD_PJ\LCD_PJ.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: key.c ili9488.c rx8025t.c rx8025t_example.c es1642.c es1642_usage_guide.c device_manager.c rs485_usart.c user_data_manager.c host_comm.c battery.c mppt.c bank_switch.c main.c gpio.c freertos.c adc.c crc.c dma.c fmc.c i2c.c iwdg.c rtc.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c ota_upgrade.c
    ../Core/Inc/: ota_upgrade.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group LVGL_Src
    ../Middlewares/LVGL_v8.3.11/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/others/msg/: lv_msg.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/extra/: lv_extra.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/LVGL_v8.3.11/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_Porting
    ../Middlewares/LVGL_v8.3.11/lvgl/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group LVGL_Config
    ../Middlewares/LVGL_v8.3.11/lvgl/: lv_conf.h
  group LVGL_myGui
    ../Middlewares/LVGL_v8.3.11/lvgl/myGUI/custom/: custom.c custom.h lv_conf_ext.h
    ../Middlewares/LVGL_v8.3.11/lvgl/myGUI/generated/guider_customer_fonts/: guider_customer_fonts.h
    ../Middlewares/LVGL_v8.3.11/lvgl/myGUI/generated/guider_fonts/: lv_font_SourceHanSerifSC_Regular_16.c lv_font_SourceHanSerifSC_Regular_12.c lv_font_montserratMedium_48.c lv_font_weather_16.c
    ../Middlewares/LVGL_v8.3.11/lvgl/myGUI/generated/: events_init.c events_init.h gui_guider.c gui_guider.h widgets_init.c widgets_init.h setup_scr_screen_user_detail.c setup_scr_screen_solar.c setup_scr_screen_user_list.c setup_scr_screen_user_home.c setup_scr_Startup_screen.c setup_scr_screen_alert.c setup_scr_screen_tcp_setting.c setup_scr_screen_sys_setting.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group W5500_Ethernet
    ../Middlewares/W5500/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../Middlewares/W5500/ioLibrary_Driver/Ethernet/W5500/: w5500.c
  group W5500_Internet
    ../Middlewares/W5500/ioLibrary_Driver/Internet/DHCP/: dhcp.c
  group W5500_User
    ../Middlewares/W5500/user_main/: user_main.c tcp_cmd_handler.c ota_tcp_handlers.c
    ../Middlewares/W5500/wiz_interface/: wiz_interface.c
    ../Middlewares/W5500/wiz_platform/: wiz_platform.c
  group A7680C
    ../Core/Src/: a7680c.c a7680c_at.c a7680c_mqtt.c a7680c_http.c a7680c_netmgr.c
software components: CMSIS:CORE 4.3.0
